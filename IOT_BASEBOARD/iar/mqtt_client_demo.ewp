# IAR project mqtt_client_demo.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_STM32F4XX_NUCLEO_144; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\cmsis\include; ..\..\..\..\..\third_party\st\devices\stm32f4xx; ..\..\..\..\..\third_party\st\boards; ..\..\..\..\..\third_party\st\boards\common; ..\..\..\..\..\third_party\st\boards\stm32f4xx_nucleo_144; ..\..\..\..\..\third_party\st\stm32f4xx_hal_driver\inc; ..\..\..\..\..\third_party\freertos\include; ..\..\..\..\..\third_party\freertos\portable\iar\arm_cm4f; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_ssl; ..\..\..\..\..\cyclone_crypto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F429xx; USE_STM32F4XX_NUCLEO_144; USE_HAL_DRIVER
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: IOT_BASEBOARD.hex
  ILINK.IlinkOutputFile: mqtt_client_demo.out
  ILINK.IlinkIcfFile: stm32f429_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: mqtt_client_demo.srec
  ILINK.IlinkIcfFile: stm32f429_sram.icf
  group Common Headers
    ../../../../../common/: cpu_endian.h date_time.h debug.h error.h os_port.h os_port_freertos.h str.h
  group Common Sources
    ../../../../../common/: cpu_endian.c date_time.c os_port_freertos.c str.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/cipher/: aes.h aria.h camellia.h chacha.h des.h des3.h idea.h rc4.h seed.h
    ../../../../../cyclone_crypto/encoding/: asn1.h base64.h oid.h
    ../../../../../cyclone_crypto/cipher_mode/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h chacha20_poly1305.h gcm.h
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/ecc/: curve25519.h curve448.h ec.h ec_curves.h ecdh.h ecdsa.h x25519.h x448.h
    ../../../../../cyclone_crypto/pkc/: dh.h dsa.h rsa.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/certificate/: pem_import.h x509_cert_parse.h x509_cert_validate.h x509_common.h
    ../../../../../cyclone_crypto/rng/: yarrow.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/cipher/: aes.c aria.c camellia.c chacha.c des.c des3.c idea.c rc4.c seed.c
    ../../../../../cyclone_crypto/encoding/: asn1.c base64.c oid.c
    ../../../../../cyclone_crypto/cipher_mode/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c chacha20_poly1305.c gcm.c
    ../../../../../cyclone_crypto/ecc/: curve25519.c curve448.c ec.c ec_curves.c ecdh.c ecdsa.c x25519.c x448.c
    ../../../../../cyclone_crypto/pkc/: dh.c dsa.c rsa.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/certificate/: pem_import.c x509_cert_parse.c x509_cert_validate.c x509_common.c
    ../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: ssl_misc.h tls.h tls_cache.h tls_certificate.h tls_cipher_suites.h tls_client.h tls_client_misc.h tls_common.h tls_handshake.h tls_handshake_hash.h tls_handshake_misc.h tls_key_material.h tls_misc.h tls_record.h tls_server.h tls_server_misc.h tls_signature.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: ssl_misc.c tls.c tls_cache.c tls_certificate.c tls_cipher_suites.c tls_client.c tls_client_misc.c tls_common.c tls_handshake.c tls_handshake_hash.c tls_handshake_misc.c tls_key_material.c tls_misc.c tls_record.c tls_server.c tls_server_misc.c tls_signature.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/ipv4/: arp.h icmp.h igmp.h ipv4.h ipv4_frag.h
    ../../../../../cyclone_tcp/core/: bsd_socket.h ethernet.h ip.h net.h net_mem.h nic.h raw_socket.h socket.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/ipv6/: icmpv6.h ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_common.h mdns_responder.h
    ../../../../../cyclone_tcp/mqtt/: mqtt_client.h mqtt_client_misc.h mqtt_client_packet.h mqtt_client_transport.h mqtt_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_common.h nbns_responder.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32f4x9_eth_driver.h
    ../../../../../cyclone_tcp/web_socket/: web_socket.h web_socket_auth.h web_socket_frame.h web_socket_misc.h web_socket_transport.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/ipv4/: arp.c icmp.c igmp.c ipv4.c ipv4_frag.c
    ../../../../../cyclone_tcp/core/: bsd_socket.c ethernet.c ip.c net.c net_mem.c nic.c raw_socket.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/ipv6/: icmpv6.c ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_common.c mdns_responder.c
    ../../../../../cyclone_tcp/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c mqtt_client_transport.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32f4x9_eth_driver.c
    ../../../../../cyclone_tcp/web_socket/: web_socket.c web_socket_auth.c web_socket_frame.c web_socket_misc.c web_socket_transport.c
  group Demo Headers
    ../src/: crypto_config.h FreeRTOSConfig.h net_config.h os_port_config.h stm32f4xx_hal_conf.h stm32f4xx_it.h tls_config.h
  group Demo Sources
    ../src/: debug.c dma.c eeprom.c eeprom_4seri.c gpio.c Http_Read_Parser.c Http_Read_parser.h lcd.c lcd.h lcd_hd44780.c Lora_Sensor.c Lora_Sensor.h main.c main.h menu.c parson.c rf_modules.c rf_modules.h rtc.c stm32f4xx_it.c system_stm32f4xx.c usart.c
    ./: startup_stm32f429xx.s
  group FreeRTOS Headers
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
    ../../../../../third_party/freertos/portable/iar/arm_cm4f/: portmacro.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
    ../../../../../third_party/freertos/portable/iar/arm_cm4f/: port.c portasm.s
  group Nucleo-F429ZI Headers
    ../../../../../third_party/st/boards/stm32f4xx_nucleo_144/: stm32f4xx_nucleo_144.h
  group Nucleo-F429ZI Sources
    ../../../../../third_party/st/boards/stm32f4xx_nucleo_144/: stm32f4xx_nucleo_144.c
  group STM32F4xx HAL Drivers Headers
    ../../../../../third_party/st/stm32f4xx_hal_driver/inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group STM32F4xx HAL Drivers Sources
    ../../../../../third_party/st/stm32f4xx_hal_driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
