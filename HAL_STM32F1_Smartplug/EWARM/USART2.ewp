# IAR project USART2.ewp, settings and files
configuration USART2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../comm_libs; ../env; ../smartplug; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART2.hex
  ILINK.IlinkOutputFile: USART2.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/comm_libs
    ../comm_libs/: checksum.c checksum.h circularq.c circularq.h comm_dbg.c comm_dbg.h comm_def.h comm_relay.h comm_str.c comm_str.h comm_sys.c comm_sys.h comm_uart.c comm_uart.h crc16.c crc16.h KEPCO_struct.h modem_hw2.h NMS_format.c NMS_format.h NMS_proto.c SM_NMS.c SM_NMS.h SM_V9871.c SM_V9871.h V9871_format.h
  group Application/env
    ../env/: platform_env.h
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/smartplug
    ../smartplug/: if_nms.c if_nms.h if_vango.c if_vango.h NMS_proto.h smartplug_cfg.c smartplug_cfg.h smartplug_cli.c smartplug_cli.h smartplug_def.h smartplug_flash.c smartplug_flash.h smartplug_func.c smartplug_func.h smartplug_func_boot.c smartplug_func_init.c smartplug_func_rdy.c smartplug_func_run.c smartplug_hw.c smartplug_hw.h smartplug_impl.c smartplug_impl.h smartplug_it.c smartplug_it.h smartplug_led.c smartplug_led.h smartplug_stat.c smartplug_stat.h smartplug_struct.h
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
